Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Nalu-Sofa 2 seater - ver4.ifc
Time: 2024-10-24T16:09:57
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (4)
Name
 | Nalu-Sofa 2 seater_0 - ObjectType: SketchupGroup
 | Nalu-Sofa 2 seater_1 - ObjectType: SketchupGroup
 | Nalu-Sofa 2 seater_2 - ObjectType: SketchupGroup
 | Nalu-Sofa 2 seater_3 - ObjectType: SketchupGroup
